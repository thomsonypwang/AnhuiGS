# Keil uVision project gateway_board.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: HC32F4A0PITB HDSC
  pack: HDSC.HC32F4A0.1.0.7
  cpu: IRAM(0x1FFE0000,0x80000) IROM(0x00000000,0x200000) IROM2(0x03000000,0x1800) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: gateway_board +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: __DEBUG,HC32F4A0,USE_DDL_DRIVER
  c include: .\app;.\cmsis;.\cmsis\Include;.\drivers\inc;.\components\freertos;.\components\freertos\include;.\components\freertos\portable\GCC\ARM_CM4F;.\components\os;.\components\sys_libc;.\components\sys_time;.\components\healthmon;.\components\psm;.\peripheral_drivers\qspi_w25q64;.\peripheral_drivers\rtc;.\peripheral_drivers\wdt;.\peripheral_drivers\w5500;.\peripheral_drivers\am2301a;.\peripheral_drivers\autoeclosing_driver;.\peripheral_drivers\bat;.\peripheral_drivers\ble_lock_driver;.\peripheral_drivers\buzzer;.\peripheral_drivers\camera_rs232_driver;.\peripheral_drivers\gps_driver;.\peripheral_drivers\key;.\peripheral_drivers\led;.\peripheral_drivers\monitor_board_driver;.\peripheral_drivers\nb_driver;.\peripheral_drivers\oled;.\peripheral_drivers\sensor_input;.\components\net\eth_w5500;.\components\mqtt;.\components\at_nb_device;.\components\jsmn;.\components\json_generator;.\components\json_parser;.\app\eht_http_server;.\peripheral_drivers\circuit_breaker_driver
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x3000000 size 0x1800
  memory RVCT9: RAM 0x1ffe0000 size 0x80000
  scatter file: .\cmsis\config\linker\HC32F4A0xI.sct
  link misc: --keep=*Handler
  group app
    ./app/: main.c project_config.h project_pin_use_config.h hc32f4xx_conf.h project_psm_control.c project_psm_control.h gps_control.c gps_control.h key_handle.c key_handle.h lock_rs485_handle.c lock_rs485_handle.h monitor_board_handle.c monitor_board_handle.h nb_iot_mqtt_handle.c nb_iot_mqtt_handle.h oled_handle.c oled_handle.h autoeclosing_rs485_handle.c autoeclosing_rs485_handle.h camera_handle.c camera_handle.h eth_to_freertos.c eth_to_freertos.h eth_to_mqtt.c eth_to_mqtt.h eth_handle.c eth_handle.h eth_mqtt_handle.c eth_mqtt_handle.h circuit_breaker_rs485_handle.c circuit_breaker_rs485_handle.h
  group cmsis
    ./cmsis/: hc32f4a0.h hc32f4xx.h startup_hc32f4a0.s system_hc32f4a0.c system_hc32f4a0.h
  group drivers
    ./drivers/src/: hc32_ll.c hc32_ll_adc.c hc32_ll_aes.c hc32_ll_aos.c hc32_ll_can.c hc32_ll_clk.c hc32_ll_cmp.c hc32_ll_crc.c hc32_ll_ctc.c hc32_ll_dac.c hc32_ll_dcu.c hc32_ll_dma.c hc32_ll_dmc.c hc32_ll_dvp.c hc32_ll_efm.c hc32_ll_emb.c hc32_ll_eth.c hc32_ll_event_port.c hc32_ll_fcg.c hc32_ll_fcm.c hc32_ll_fmac.c hc32_ll_gpio.c hc32_ll_hash.c hc32_ll_hrpwm.c hc32_ll_i2c.c hc32_ll_i2s.c hc32_ll_icg.c hc32_ll_interrupts.c hc32_ll_keyscan.c hc32_ll_mau.c hc32_ll_mpu.c hc32_ll_nfc.c hc32_ll_ots.c hc32_ll_pwc.c hc32_ll_qspi.c hc32_ll_rmu.c hc32_ll_rtc.c hc32_ll_sdioc.c hc32_ll_smc.c hc32_ll_spi.c hc32_ll_sram.c hc32_ll_swdt.c hc32_ll_tmr0.c hc32_ll_tmr2.c hc32_ll_tmr4.c hc32_ll_tmr6.c hc32_ll_tmra.c hc32_ll_trng.c hc32_ll_usart.c hc32_ll_utility.c hc32_ll_wdt.c hc32f4a0_ll_interrupts_share.c
  group peripheral_drivers
    ./peripheral_drivers/qspi_w25q64/: flash_drv.c flash_drv.h qspi_flash.c qspi_flash.h
    ./peripheral_drivers/rtc/: rtc_drv.c rtc_drv.h
    ./peripheral_drivers/wdt/: wdt_drv.c wdt_drv.h
    ./peripheral_drivers/w5500/: w5500.c w5500.h w5500_dir.c w5500_dir.h wizchip_conf.c wizchip_conf.h
    ./peripheral_drivers/am2301a/: am2301a_dir.c am2301a_dir.h
    ./peripheral_drivers/autoeclosing_driver/: autoeclosing_rs485_dir.c autoeclosing_rs485_dir.h
    ./peripheral_drivers/bat/: bat_dir.c bat_dir.h
    ./peripheral_drivers/ble_lock_driver/: lock_rs485_dir.c lock_rs485_dir.h
    ./peripheral_drivers/buzzer/: buzzer_dir.c buzzer_dir.h
    ./peripheral_drivers/camera_rs232_driver/: camera_com_pro.c camera_com_pro.h camera_dir.c camera_dir.h
    ./peripheral_drivers/gps_driver/: gps_dir.c gps_dir.h
    ./peripheral_drivers/key/: key_dir.c key_dir.h
    ./peripheral_drivers/led/: led_dir.c led_dir.h
    ./peripheral_drivers/monitor_board_driver/: monitor_board_dir.c monitor_board_dir.h
    ./peripheral_drivers/nb_driver/: nb_uart_dir.c nb_uart_dir.h
    ./peripheral_drivers/oled/: oled_dir.c oled_dir.h oledfont.h
    ./peripheral_drivers/sensor_input/: sensor_in_dir.c sensor_in_dir.h
    ./peripheral_drivers/circuit_breaker_driver/: circuit_breaker_rs485_dir.c circuit_breaker_rs485_dir.h
  group freertos
    ./components/freertos/: croutine.c event_groups.c FreeRTOSConfig.h list.c queue.c stream_buffer.c tasks.c timers.c
    ./components/freertos/portable/GCC/ARM_CM4F/: port.c portmacro.h
    ./components/freertos/portable/MemMang/: heap_4.c
  group os
    ./components/os/: sys_os.c sys_os.h sys_errno.h sys_log.h sys_assert.c sys_assert.h sys_work_queue.c sys_work_queue.h work_queue.c work_queue.h sys_list.h
  group psm
    ./components/psm/: partition.c partition.h psm_crc32.c psm_crc32.h soft_md5.c soft_md5.h psm_internal.h psm_list.h psm_v2.c psm_v2.h
  group sys_libc
    ./components/sys_libc/: strnlen.c console.c sys_stdio.c sys_stdio.h sys_utils.c sys_utils.h
  group sys_time
    ./components/sys_time/: hwrtc.c swrtc.c sys_time.c sys_time.h
  group healthmon
    ./components/healthmon/: healthmon.c healthmon.h
  group net
    ./components/net/eth_w5500/: w5500_dhcp.c w5500_dhcp.h w5500_dns.c w5500_dns.h w5500_socket.c w5500_socket.h
  group eht_http_server
    ./app/eht_http_server/: http_parser.c http_parser.h http_server.c http_server.h http_util.c http_util.h webpage.h
  group mqtt
    ./components/mqtt/: MQTTConnect.h MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTFormat.h MQTTPacket.c MQTTPacket.h MQTTPublish.h MQTTSerializePublish.c MQTTSubscribe.h MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribe.h MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c StackTrace.h
  group at_nb_device
    ./components/at_nb_device/: aiot_at_client_api.c aiot_at_client_api.h aiot_module_api.c aiot_module_api.h aiot_mqtt_api.c aiot_mqtt_api.h aiot_state_api.c aiot_state_api.h core_config.h core_list.h core_log.c core_log.h core_queue.h core_ring_buffer.c core_ring_buffer.h core_stdinc.h core_string.c core_string.h core_sysdep.c core_sysdep.h posix_port.c posix_port.h
  group jsmn
    ./components/jsmn/: jsmn.c jsmn.h
  group json_generator
    ./components/json_generator/: json_generator.c json_generator.h
  group json_parser
    ./components/json_parser/: json_parser.c json_parser.h
software components: CMSIS:CORE 5.6.0
